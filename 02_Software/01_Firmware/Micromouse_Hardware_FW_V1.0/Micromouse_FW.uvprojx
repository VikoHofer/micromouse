# Keil uVision project Micromouse_FW.uvprojx, settings and files
target Source (6240000::V6.24::ARMCLANG)
  device: STM32F446RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Micromouse_FW
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=3
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group main
    ./: main.c
  group motor
    ./: MotorDriver.c MotorDriver.h
  group IR_sensor
    ./: sensor.c sensor.h TimeOfLight.c TimeOfLight.h
  group encoder
    ./: encoder.h encoder.c
  group button
    ./: board_button.h board_button.c
  group led
    ./: BOARD_LED.c BOARD_LED.h
  group config
    ./: clock_config.c clock_config.h
  group adc
    ./: adc.c adc.h
  group Debugging
    ./: Uart.h Uart.c Print.h Print.c Python_Debugger.h Python_Debugger.c BLEDebugger.c BLEDebugger.h
  group FloodFill
    ./: FloodFill.c FloodFill.h Refresh.c Refresh.h Queue.c Queue.h Diagonal.c Diagonal.h TimeFloodFill.c TimeFloodFill.h
  group Timer
    ./: Timer.c Timer.h
  group drive_control
    ./: profile.h profile.c motion_control.h motion_control.c sensor_normalize.h sensor_normalize.c
  group Delay
    ./: Delay.h Delay.c
  group Statemachine
    ./: StateMachine.h StateMachine.c State_Initialize.c State_SolveMaze.c State_FastRun.c
  group current_Sensor
    ./: current_sensor.c current_sensor.h
  group system_config
    ./: config.h
  group Imu
    ./: imu_test.c imu_test.h
software components: CMSIS:CORE 6.1.1, Device:STM32Cube Framework:Classic 1.8.1, Device:STM32Cube HAL:ADC 1.8.1, Device:STM32Cube HAL:Common 1.8.1, Device:STM32Cube HAL:Cortex 1.8.1, Device:STM32Cube HAL:DMA 1.8.1, Device:STM32Cube HAL:EXTI 1.8.1, Device:STM32Cube HAL:GPIO 1.8.1, Device:STM32Cube HAL:I2C 1.8.1, Device:STM32Cube HAL:PWR 1.8.1, Device:STM32Cube HAL:RCC 1.8.1, Device:STM32Cube HAL:TIM 1.8.1, Device:STM32Cube HAL:UART 1.8.1, Device:Startup 2.6.3
