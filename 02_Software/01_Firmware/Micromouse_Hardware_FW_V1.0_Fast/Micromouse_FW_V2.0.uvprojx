# Keil uVision project Micromouse_FW_V2.0.uvprojx, settings and files
target Source (6240000::V6.24::ARMCLANG)
  device: STM32F446RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Micromouse_FW_V2.0
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group main
    ./: main.c
  group statemachine
    ./: State_Initialize.c State_SolveMaze.c Statemachine.c StateMachine.h
  group system_config
    ./: clock_config.c clock_config.h Delay.c Delay.h config.h config_hw_v1.h board_config.h
  group debug
    ./: BLEDebugger.c BLEDebugger.h Uart.c Uart.h
  group peripherals
    ./: board_button.c board_button.h board_led.c board_led.h
  group motors
    ./: motor_driver.c motor_driver.h
  group encoder
    ./: encoder.c encoder.h
  group timer
    ./: timer.c timer.h
  group motion_control
    ./: motion_control.c motion_control.h system_analysis.h system_analysis.c
  group imu
    ./: imu_test.c imu_test.h bno055_hal.h bno055_hal.c
  group profiler
    ./: profile.h
  group lock
    ./: Lock.c Lock.h
  group FloodFill
    ./: Diagonal.c Diagonal.h FloodFill.c FloodFill.h profile.c Queue.c Queue.h Refresh.c Refresh.h
  group sensing
    ./: wall_following.c wall_sensors_ir.c wall_following_ir.c wall_following.h wall_sensors_ir.h wall_following_ir.h
  group ir
    ./: sensor.h sensor.c sensor_normalize.h sensor_normalize.c
  group adc
    ./: adc.h adc.c
software components: CMSIS:CORE 6.1.1, Device:STM32Cube Framework:Classic 1.8.1, Device:STM32Cube HAL:ADC 1.8.1, Device:STM32Cube HAL:Common 1.8.1, Device:STM32Cube HAL:Cortex 1.8.1, Device:STM32Cube HAL:DMA 1.8.1, Device:STM32Cube HAL:EXTI 1.8.1, Device:STM32Cube HAL:GPIO 1.8.1, Device:STM32Cube HAL:I2C 1.8.1, Device:STM32Cube HAL:PWR 1.8.1, Device:STM32Cube HAL:RCC 1.8.1, Device:STM32Cube HAL:TIM 1.8.1, Device:STM32Cube HAL:UART 1.8.1, Device:STM32Cube HAL:USART 1.8.1, Device:Startup 2.6.3
